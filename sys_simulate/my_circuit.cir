* Generated by LTspice 24.1.10 for Windows.
R1 N002 Vin 13k
R2 N003 N002 1Meg
C1 N002 0 0.1u
C2 N003 0 0.01u
C3 N003 N006 2p
R3 N006 0 100Meg
C4 N004 N006 0.1u
C5 N005 N004 3p
R4 N005 N004 100Meg
XU1 0 N004 Vcc Vee N005 level2 Avol=1Meg GBW=10Meg
XU2 N011 N008 Vcc Vee N008 level2 Avol=1Meg GBW=10Meg
XU3 N010 N009 Vcc Vee N009 level2 Avol=1Meg GBW=10Meg
C6 N011 N005 0.1u
C7 0 N010 0.1u
R5 N011 0 28
R6 N010 N008 28
V2 Vcc 0 5
V3 0 Vee 5
XU4 N009 N007 Vcc Vee Vout level2 Avol=1Meg GBW=10Meg
R7 N007 0 1
R8 Vout N007 103

.end
